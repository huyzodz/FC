# Keil uVision project main.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-sign-conversion -w
  c include: .\test\inc;.\main;.\lib\inc;.\main\driver;.\main\flight;.\main\scheduler;.\main\system;.\simulation
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group main
    ./main/: main.c
  group lib
    ./lib/: clock.c dma.c dshot.c gpio.c i2c_master.c usart.c timer.c spi_master.c adc.c
  group test
    ./test/: test_i2c.c test_bmi270.c test_task.c test_spi.c test_vl53l1x.c test_adc.c
  group system
    ./main/system/: init.c
  group driver
    ./main/driver/: imu_bmi270.c rasp_com.c gps_be880.c barometer_dps310.c vl53l1x.c batery.c
  group flight
    ./main/flight/: esekf.c pid.c smc.c drone.c task.c mixer.c
  group scheduler
    ./main/scheduler/: drone_scheduler.c
  group simulation
    ./simulation/: simulate.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.0
